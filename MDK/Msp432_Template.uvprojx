# Keil uVision project Msp432_Template.uvprojx, settings and files
target Msp432_Template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432.1.0.0
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x01000000,0x00010000) IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Msp432_Gimbal +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: __MSP432P401R__,TARGET_IS_MSP432P4XX,keil,__FPU_PRESENT,__TARGET_FPU_VFP,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\App;..\Bsp;..\Ti_Driver\inc;..\Ti_Driver\driverlib\MSP432P4xx;..\FreeRTOS;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\FreeRTOS\Common\include;..\DSP_Lib\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
  group Bsp
    ../Bsp/: bsp_button.c bsp_clock.c bsp_delay.c bsp_flash.c bsp_gimbal.c bsp_iic.c bsp_led.c bsp_pwm.c bsp_rgb.c bsp_spi.c bsp_uart.c bsp_adc.c bsp_ads1292.c bsp_st7789.c
  group App
    ../App/: app_dt.c app_math.c
  group User
    ./: main.c
    ../Bsp/: msp432_it.c
  group Ti_DriverLib
    ../Ti_Driver/driverlib/MSP432P4xx/keil/: msp432p4xx_driverlib.lib
  group Dsp_Lib
    ../DSP_Lib/: arm_cortexM4lf_math.lib
  group FreeRTOS
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c FreeRTOSConfig.h
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group Doc
    ../Doc/: Readme.txt
software components: CMSIS:CORE 5.4.0, Device:Startup 3.2.2
